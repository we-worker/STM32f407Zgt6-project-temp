# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\LCD;..\USER\LED;..\USER\usart1;..\USER\KEY;..\USER\ADC;..\USER;..\USER\TOUCH;..\USER\DAC;..\STM32F4_FWLIB\DSP;..\USER\Screen;..\USER\Uart;..\USER\DDS;..\USER\APPS;..\USER\Timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group USER
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/KEY/: key.c Input_event.c
    ../USER/ADC/: adc.c
    ../USER/TOUCH/: touch.c
    ../USER/DAC/: dac.c
    ../USER/APPS/: fft.c pid.c
    ../USER/Timer/: timer.c timer4.c timer9_phase.c
  group Screens
    ../USER/Screen/: 05D_UI.c Screen_main.c UI.c Wave_page.c Screen3.c
  group DSP
    ../STM32F4_FWLIB/DSP/: arm_cortexM4lf_math.lib
  group DDS
    ../USER/DDS/: AD9833.c
  group UART
    ../USER/Uart/: valuepack.c
  group Common
    ../Common/: common.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_dma.c
    ../USER/TOUCH/: xpt2046.c
software components: CMSIS:CORE 5.6.0
